<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USART.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\GPIO_LED\GPIO_LED.ewp</path>
    </project>
    <batchBuild />
</workspace>
