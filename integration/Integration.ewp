# IAR project Integration.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: firmware; Libraries/CMSIS/Device/ST/STM32F4xx/Include; Libraries/STM32F4xx_StdPeriph_Driver/inc; Libraries/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Integration.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$/config/linker/ST/stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    firmware/: comm.c game.c hit_detector.c main.c motor.c protocol.c sensors.c servo.c startup_stm32f411xe.s system_stm32f4xx.c timebase.c
    ../../../../Documents/stsw-stm32065_v1-9-0/STM32F4xx_DSP_StdPeriph_Lib_V1.9.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
